Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Versão 1.0
Time: 2022-10-13T15:03:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 13 15:03:24 2022 * Host: acadbim09 * Database: C:\Users\acadbim\AppData\Local\Temp\46461fa1-5daa-42ee-a6e9-52bab5b2eae2\085d1488-273b-44ad-af0a-bc5ecf74ab20\ifc * Database version: 5507 * Database creation date: Thu Oct 13 15:03:22 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 13 15:03:22 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 13 15:03:22 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Versão 1.0
LongName: BIM Elements; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcElectricDistributionPoint: TEKA_2902011_Floor_Rack_19p_47U_800x1000x2200_PT:TEKA_2902011_Floor_Rack_19p_47U_800x1000x2200_PT, 48
In: Level 1
Material: Plastico Preto RAL 9005, RAL 9018, Aço Laminado a Frio SPCC, Inox, Vidro temperado de 5mm
Pset_DistributionFlowElementCommon - Reference: TEKA_2902011_Floor_Rack_19p_47U_800x1000x2200_PT; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: TEKA
Pset_ProductRequirements - Category: Electrical Equipment
01 GERAL - 01.01 Fabricante: Teka; 01.02 Modelo: 2902011; 01.03 Gama: Bastidor; 01.04 Familia: Bastidor Pavimento; 01.05 Produto: Bastidor 19", 47U; 01.06 Descricao: Bastidor Pavimento 19" - 47U (800 x 1000 x 2200); 01.07 Mark_ID: VI 1; 01.08 Autor: ACADBIM
02 MATERIAIS - 02.01 Cor_Caixa: Preto (RAL 9005); 02.02 Material_Caixa: Aço Laminado a Frio SPCC; 02.03 Material_Porta_Frontal: Vidro temperado de 5mm; 02.04 Tratamento_Superficie: Fosfatação e lacagem com epoxy-polyester texturado
03 TECNICAS - 03.01 Dimensoes: 800 x 1000 x 2200; 03.02 Carga_Maxima [Kg]: 800; 03.03 Unidades_Rack [Un]: 47; 03.04 Original Family Name: TEKA_2902011_Floor_Rack_19p_47U_800x1000x2200_PT: TEKA_2902011_Floor_Rack_19p_47U_800x1000x2200_PT
